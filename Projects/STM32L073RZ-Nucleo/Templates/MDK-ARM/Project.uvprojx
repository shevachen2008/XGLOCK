# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RBHx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: V4Lock +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L0XX_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_adc.c stm32l0xx_hal_uart.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_spi.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_rng.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_dma.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_lcd.c stm32l0xx_hal_tim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_dac.c stm32l0xx_hal_irda.c
  group Example/User
    ../Src/: stm32l0xx_it.c main.c stm32l0xx_hal_msp.c I2c.c Hardware.c Rtc.c Flash.c Motor.c Access.c Encpt.c LockKey.c Sys.c Sys_GenFun.c BC26.c Comble.c ComNB.c ADC.c Pwr_stop.c Agtest.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
software components: CMSIS:CORE 4.3.0
